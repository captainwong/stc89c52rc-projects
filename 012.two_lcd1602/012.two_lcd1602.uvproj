# Keil uVision project 012.two_lcd1602.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: 012.two_lcd1602 +hex
  c flags: Optimize=9 SizeSpeed=1
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: main.c lcd1.c lcd2.c
    ../lib/: delay.c iic.c lcd1602_iic.c lcd1602.c
